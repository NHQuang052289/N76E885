# Keil uVision project Prj.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: Prj
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_221184
  c include: .\INC
  group Startup
    ./: STARTUP.A51
  group SRC
    ./SRC/: Common.c Delay.c Version.c
    ./: main.c
  group INC
    ./INC/: Common.h Define.h Delay.h Function_Define.h N76E885.h SFR_Macro.h Typedef.h Version.h
