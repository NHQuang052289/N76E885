# Keil uVision project GPIO.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: GPIO +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_221184
  c include: ..\..\Include;.\Code
  group Source Group 1
    ./Code/: GPIO.C EEPROM.c EEPROM.h I2C.c I2C.h
  group Common
    ../../Common/: Common.c Delay.c Version.c
  group Startup
    ../../Startup/: STARTUP.A51
